## Kconfig
```kconfig
mainmenu "Niel Acuna Advent of Code"

menu "AoC 2024"
source 2024/Kconfig
endmenu

menu "AoC 2025"
source 2025/Kconfig
endmenu
```
